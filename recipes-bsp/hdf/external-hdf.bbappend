HDF_PATH = "github.com/embed-me/ebaz4205_xsa.git;branch=rel-v2020.1"
HDF_NAME = "ebaz4205_top.xsa"

HDF_MACHINE = ""

SRCREV = "ae46e939bb43424bba9435524f5aee263a23384d"